Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2019-02-11T09:43:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 11 09:43:25 2019 * Host: B3ROBRAWR2780 * Database: C:\Users\RVI\AppData\Local\Temp\{23C239E7-1130-4DAB-8B7B-B3C9547E6431}\ifc * Database version: 5507 * Database creation date: Mon Feb 11 09:43:22 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Feb 11 09:43:22 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 11 09:43:22 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcUnitaryEquipment: AVBC-54HJFKA, HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVBC-09-54_INT-EN:AVBC-54HJFKA:8885
In: Level 1
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 245-245-245, Color RGB 072-102-244, Color RGB 180-180-180, Color RGB 187-185-183, Color RGB 168-128-048, Color RGB 075-079-084
Type - Dimensions - Depth: 950 mm; Drain Diameter: 32 mm; Height: 318 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 9.53 mm; Width: 950 mm
Type - Electrical - Cooling Running Current (A): 1.2; Heating Running Current (A): 1.1; Hertz: 50 Hz; Phase: 1; Power: 0 W; Voltage: 230 V
Type - Identity Data - Article Description: 4-Way Cassette; Article Type: AVBC-54HJFKA; Base Family Version: 11.25; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: 4-Way Cassette; EMCS Version: 4.0; ETIM Article Class: EC011580; Family Version: 11.25; Manufacturer: Hisense; Manufacturer Art. No.: AVBC-54HJFKA; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVBC-54HJFKA; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: 4-Way cassette series; Revit Version: 2017; Type Name: AVBC-54HJFKA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Dark Grey: Color RGB 110-110-110; Grey: Color RGB 180-180-180; Logo: Color RGB 075-079-084; Transparent Blue: Color RGB 072-102-244; White: Color RGB 245-245-245; Yellow: Color RGB 168-128-048
Type - Mechanical - Loads - Airflow Rate (m3/min): 36.1; Cooling Capacity (kW): 16; Cooling Power Input (kW): 0.13; Heating Capacity (kW): 18; Heating Power Input (kW): 0.13; Motor Power: 127; Sound Pressure Level (dB(A)): 46; Unit Weight (kg): 31.7
Type - Other - Category: Mechanical Equipment; Family Name: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVBC-09-54_INT-EN; Gas Diameter: 24.4 mm; Height of the Body: 288 mm; Liquid Diameter: 17.2 mm; Panel Model: HP-G-NK; Void Height: 288 mm; Void Height Safe: 288 mm; Void Length: 600 mm; Void Width: 600 mm
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 25.85 m2; Ceiling Offset: 0 mm; Volume: 0.214444 m3
Identity Data - Mark: 1
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Undefined,Sanitary,Power
Other - Back Clearance Safe: 1500 mm; Bottom Clearance Safe: 1000 mm; Ceiling Offset Safe: 246 mm; Family: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVBC-09-54_INT-EN: AVBC-54HJFKA; Family and Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVBC-09-54_INT-EN: AVBC-54HJFKA; Front Clearance Safe: 1500 mm; Left Clearance Safe: 1500 mm; Offset from Ceiling: 288 mm; Right Clearance Safe: 1500 mm; Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVBC-09-54_INT-EN: AVBC-54HJFKA; Type Id: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVBC-09-54_INT-EN: AVBC-54HJFKA
Phasing - Phase Created: New Construction
Visibility - Back Clearance: 1500 mm; Bottom Clearance: 1000 mm; Front Clearance: 1500 mm; Left Clearance: 1500 mm; Right Clearance: 1500 mm; Service Space: no
